Properties of the parts of a building model (IFC4), part 2 of 3

# IfcBuildingElementProxy: 4 миди.stp[335]
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[398]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[417]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[418]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[419]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[420]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[421]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[422]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[423]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[424]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[425]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[426]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[427]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[428]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[429]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[430]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[431]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[432]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[433]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[434]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[435]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[436]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[437]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[438]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[439]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[440]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[441]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[442]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[443]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[444]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[445]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[446]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[447]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[448]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[449]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[450]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[451]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[452]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[453]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[454]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[455]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[456]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[457]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[458]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[459]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[460]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[461]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[462]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[463]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[464]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[465]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[466]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[467]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[468]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[469]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[470]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[471]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[472]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[473]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[474]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[475]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[476]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[477]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[478]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[479]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[480]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[481]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[482]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[483]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[484]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[485]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[486]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[487]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[488]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[489]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[490]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[491]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[492]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[493]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[494]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[495]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[496]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[497]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[498]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[499]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[500]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[501]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[502]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[503]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[504]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[505]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[506]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[507]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[508]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[509]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[510]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[511]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[512]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[513]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[514]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[515]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[516]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[517]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[518]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[519]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[520]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[521]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[522]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[523]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[524]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[525]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[526]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[527]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[528]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[529]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[530]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[531]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[532]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[533]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[534]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[535]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[536]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[537]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[538]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[539]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[540]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[541]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[542]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[543]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[544]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[545]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[546]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[547]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[548]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[549]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[550]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[551]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[552]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[553]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[554]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[555]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[556]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[557]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[558]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[559]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[560]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[561]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[562]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[563]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[564]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[565]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[566]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[567]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[568]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[569]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[570]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[571]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[572]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[573]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[574]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[575]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[576]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[577]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[578]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[579]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[580]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[581]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[582]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[583]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[584]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[585]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[586]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[587]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[588]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[589]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[590]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[591]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[592]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[593]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[594]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[595]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[596]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[597]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[598]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[599]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[600]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[601]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[602]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[603]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[604]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[605]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[606]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[607]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[608]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[609]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[610]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[611]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[612]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[613]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[614]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[615]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[616]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[617]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[618]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[619]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[620]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[621]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[622]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[623]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[624]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[625]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[626]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[627]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[628]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[629]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[630]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[631]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[632]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[633]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[634]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[635]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[636]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[637]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[638]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[639]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[640]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[641]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[642]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[643]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[644]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[645]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[646]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[647]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[648]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[649]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[650]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[651]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[652]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[653]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[654]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[655]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[656]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[657]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[658]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[659]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[660]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[661]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[662]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[663]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[664]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[665]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[666]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[667]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[668]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[669]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[670]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[671]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[672]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[673]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[674]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[675]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[676]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[677]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[678]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[679]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[680]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[681]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[682]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[683]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[684]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[685]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[686]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[687]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[688]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[689]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[690]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[691]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[692]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[693]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[694]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[695]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[696]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[697]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[698]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[699]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[700]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[701]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[702]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[703]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[704]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[705]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[706]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[707]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[708]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[709]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[710]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[711]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[712]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[713]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[714]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[715]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[716]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[717]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[718]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[719]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[720]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[721]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[722]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[723]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[724]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[725]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[726]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[727]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[728]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[729]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[730]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[731]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[732]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[733]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[734]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[735]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[736]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[737]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[738]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[739]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[740]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[741]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[742]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[743]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[744]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[745]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[746]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[747]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[748]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[749]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[750]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[751]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[752]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[753]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[754]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[755]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[756]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[757]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[820]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[821]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[822]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[823]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[824]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[825]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[826]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[827]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[828]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[829]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[830]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[831]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[832]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[833]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[834]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[835]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[836]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[837]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[838]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[839]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[840]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[841]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[842]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[843]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[844]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[845]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[846]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[847]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[848]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[849]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[850]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[851]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[852]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[853]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[854]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[855]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[856]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[857]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[858]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[859]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[860]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[861]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[862]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[863]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[864]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[865]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[866]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[867]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[868]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[869]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[870]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[871]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[872]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[873]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[874]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[875]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[876]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[877]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[878]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[879]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[880]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[881]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[882]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[883]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[884]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[885]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[886]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[887]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[888]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[889]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[890]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[891]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[892]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[893]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[894]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[895]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[896]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[897]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[898]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[899]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[900]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[901]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[902]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[903]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[904]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[905]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[906]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[907]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[908]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[909]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[910]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[911]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[912]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[913]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[914]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[915]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[916]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[917]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[918]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[919]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[920]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[921]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[922]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[923]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[924]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[925]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[926]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[927]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[928]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[929]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[930]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[931]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[932]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[933]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[934]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[935]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[936]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[937]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[938]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[939]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[940]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[941]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[942]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[943]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[944]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[945]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[946]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[947]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[948]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[949]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[950]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[951]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[952]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[953]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[954]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[955]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[956]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 4 миди.stp[957]
In: Default Storey
